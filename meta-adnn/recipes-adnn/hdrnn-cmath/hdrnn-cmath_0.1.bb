SUMMARY = "A Handwritten Digit Recognition Neural Network"

DESCRIPTION = "An implementation of a Handwritten Digit Recognition Neural Network based on the MNIST Dataset"

HOMEPAGE = "https://paperbound.github.io/canvas/works.html"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0461165eed08f00dbff78a608356118f"

# DEPENDS - should later depend on a library package
