SUMMARY = "A Handwritten Digit Recognition Neural Network"
DESCRIPTION = "An implementation of a Handwritten Digit Recognition Neural Network based on the MNIST Dataset"

LICENSE =